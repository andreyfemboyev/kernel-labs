## fixtures/kbuild/Kconfig
```kconfig
mainmenu "Synthetic KERNEL//LAB fixture"

config FIXTURE
	bool "Fixture symbol"
	default y
```
